/*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>
* 文件名  ： 
* 作者    ： 董智郅
* 版本    ： V1.0.0
* 时间    ： 2019/9/16
* 简要    ： 文件说明  
********************************************************************
* 副本
*
*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>*/
/*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>
* 文件名  ： 
* 作者    ： 董智郅
* 版本    ： V1.0.0
* 时间    ： 2019/9/16
* 简要    ： 文件说明  
********************************************************************
* 副本
*
*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>*/
/* 头文件 ----------------------------------------------------------------*/
#include ".h"




/* 函数 ------------------------------------------------------------------*/

/*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
* 函数名：
* 参数：void
* 返回：void
* 描述：函数说明
~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
void (void)
{
  
}


#include <ioCC2530.h" >


#define LED1 P1_0     // P1_0定义为P1.0
#define LED2 P1_1     // P1_1定义为P1.1


//1ms精确定时
void delay(unsigned int time)
{
    unsigned int i = 0;
    unsigned int j;
    for(i = 0; i < time; i++)
    {
    for(j = 0; j < 475; j++)
    {
      asm("NOP");   
      asm("NOP");
      asm("NOP");
       }  
    }  
}

void main(void)
{
    P1SEL &= ~(0x03);
    P1DIR |= 0x03 ;   
    while(1)
{
    LED1 = 1;    
    LED2 = 0;    
    delay(1000);
    LED1 = 0;    
    LED2 = 1;     
    delay(1000);
}    
}
